Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-09-16T20:43:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 16 20:43:41 2024 * Host: Yogoon * Database: C:\Users\gokul\AppData\Local\Temp\1f8e36c5-adaa-4b78-b2d7-1296e5be0d94\e20ad4fa-3c75-4774-94cf-8a4ec060a194\ifc * Database version: 5507 * Database creation date: Mon Sep 16 20:43:41 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 16 20:43:41 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 16 20:43:41 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: BC28-3SCA, BC28-3SCA:BC28-3SCA:349242
In: Level 1
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 579 mm; Length: 116 mm; Width: 320 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Paper towel dispensers; CAWS: N13/442 Paper towel dispensers; Color: Various; Constituents: n/a; Description: DolphinRecessedStainlessSteelPaperTowelDispenser; DurationUnit: year; ExpectedLife: n/a; Finish: .1BrushedSatin_.5PowderCoated_.6CeramicCoated; Grade: 304_1.4301; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: https://www.dolphinsolutions.co.uk/product/dolphin-recessed-paper-towel-dispenser-bc28-3sca/; Material: StainlessSteel; ModelNumber: BC28-3SCA; ModelReference: DolphinSolutionsLimited_DolphinRecessedStainlessSteelPaperTowelDispenser; Name: DolphinStainlessSteel_DolphinRecessedStainlessSteelPaperTowelDispenser_BC28-3SCA; NBSCode: N13/442 Paper towel dispensers; NBSDescription: Paper towel dispensers; NominalHeight: 579; NominalLength: 116; NominalWidth: 320; ReplacementCost: n/a; Shape: Rectangle; Size: 579x116x320; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC28-3SCA; Uniclass2015Code: Pr_40_70_22_62; Uniclass2015Title: Paper towel dispensers; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Specialty Equipment; Family Name: BC28-3SCA
Type - Pset_FurnitureTypeCommon - Description: DolphinRecessedStainlessSteelPaperTowelDispenser; NominalHeight: 176479 mm; NominalLength: 35356.8 mm
Pset_ElementShading - Color: Various
Pset_ManufacturerOccurrence - BarCode: n/a
Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_DolphinRecessedStainlessSteelPaperTowelDispenser; Manufacturer: info@dolphinsolutions.co.uk
Pset_ProductRequirements - Name: DolphinStainlessSteel_DolphinRecessedStainlessSteelPaperTowelDispenser_BC28-3SCA; Category: Specialty Equipment
Pset_QuantityTakeOff - Reference: BC28-3SCA:BC28-3SCA
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.448138 m2; Volume: 0.0141576 m3
Other - Family: BC28-3SCA: BC28-3SCA; Family and Type: BC28-3SCA: BC28-3SCA; Type: BC28-3SCA: BC28-3SCA; Type Id: BC28-3SCA: BC28-3SCA
Phasing - Phase Created: New Construction
